# Repository louiscklaw/3d-printer-head-pcb

## KiCad design 001_hardware/head.kicad_pcb

File 001_hardware/README.md:

Please refer to the github page [here](https://louiscklaw.github.io/3d-printer-head-pcb/)

Parts:
C1, C2, C3: CP10uf,25V; CP_Elec_4x5.3
D1: COOL; LED_0805_2012Metric
D2: FAN; LED_0805_2012Metric
D3: HEAT; LED_0805_2012Metric
D4: PROBE; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5,rpi_like
J1: z probe; 691322110003
J2: HEATER; 691322310002
J3: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical
J4: TEMP; 691322310002
J5: COOL_FAN; 691322310002
J6: FAN; 691322310002
JP1: HOTEND_GND; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3, R4: R561,0603; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: logo_icon; logo_icon_2000

Connections:
+5V: C3.1, J1.1, J2.1, J3.3, R3.2, R4.2
/HOTEND_FAN_P: C2.1, J3.10, J6.2, R2.2
/HOTEND_HEAT_N: D3.1 (K), J2.2, J3.4, JP1.1
/HOTEND_TEMP_N: J3.6, J4.2
/HOTEND_TEMP_P: J3.5, J4.1
/PRINT_COOLING_FAN_P: C1.1, J3.8, J5.2, R1.2
/Z_PROBE_SIG: J1.3, J3.1
GND: C1.2, C2.2, C3.2, D1.1 (K), D2.1 (K), D4.1 (K), J1.2, J3.2, J3.7, J3.9, J5.1, J6.1, JP1.2
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R4.1

Notes on the sheet:
Z PROBE

Board: 2 copper layers, 29.7 x 49.8 mm, 22 parts (4 on the bottom side), 12 nets.

## Commit log

2019-09-26 init commit,
2019-09-26 update for 2019-SEP-26-print1,
2019-09-26 update for plotting,
2019-09-26 update mounting hole text,
2019-09-26 update web content,
2019-09-26 update README.md,
2019-09-26 update for SEO,
2019-09-26 fix github page link,
2019-09-26 update,
2020-02-12 update for printer head stl,
2020-03-30 update for circuits,
2020-03-30 update for adding pics,
2020-05-05 ci: init travis build config,
2020-05-05 ci: init travis token,
